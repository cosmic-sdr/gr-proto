<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>100</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>openacc_accComplexToMagPhase</key>
<param><key>id</key><value>openacc_accComplexToMagPhase_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>1</value></param>
<param><key>copy_out</key><value>0</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accComplexToMagPhase</key>
<param><key>id</key><value>openacc_accComplexToMagPhase_1</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>0</value></param>
<param><key>copy_out</key><value>0</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accMagPhaseToComplex</key>
<param><key>id</key><value>openacc_accMagPhaseToComplex_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>0</value></param>
<param><key>copy_out</key><value>0</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accMagPhaseToComplex</key>
<param><key>id</key><value>openacc_accMagPhaseToComplex_1</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>0</value></param>
<param><key>copy_out</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>openacc_accComplexToMagPhase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_0</source_block_id><sink_block_id>openacc_accMagPhaseToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_0</source_block_id><sink_block_id>openacc_accMagPhaseToComplex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_1</source_block_id><sink_block_id>openacc_accMagPhaseToComplex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_1</source_block_id><sink_block_id>openacc_accMagPhaseToComplex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>openacc_accMagPhaseToComplex_0</source_block_id><sink_block_id>openacc_accComplexToMagPhase_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accMagPhaseToComplex_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
