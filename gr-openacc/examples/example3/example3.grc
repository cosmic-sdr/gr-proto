<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>openacc_accComplexToArg</key>
<param><key>id</key><value>openacc_accComplexToArg_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>1</value></param>
<param><key>copy_out</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accComplexToMagPhase</key>
<param><key>id</key><value>openacc_accComplexToMagPhase_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>1</value></param>
<param><key>copy_out</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accComplexToMagSquared</key>
<param><key>id</key><value>openacc_accComplexToMagSquared_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>1</value></param>
<param><key>copy_out</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>openacc_accComplexToMag</key>
<param><key>id</key><value>openacc_accComplexToMag_0</value></param>
<param><key>contextType</key><value>1</value></param>
<param><key>copy_in</key><value>1</value></param>
<param><key>copy_out</key><value>1</value></param>
<param><key>deviceId</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>openacc_accComplexToArg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>openacc_accComplexToMagPhase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>openacc_accComplexToMagSquared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>openacc_accComplexToMag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToArg_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_0</source_block_id><sink_block_id>blocks_null_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagPhase_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMagSquared_0</source_block_id><sink_block_id>blocks_null_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openacc_accComplexToMag_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
