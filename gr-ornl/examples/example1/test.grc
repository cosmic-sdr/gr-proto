<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/eck/sandbox/gnuradio/ornl-add/output.txt</value></param>
<param><key>type</key><value>int</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/eck/sandbox/gnuradio/ornl-add/in0.txt</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/home/eck/sandbox/gnuradio/ornl-add/in1.txt</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_2</value></param>
<param><key>file</key><value>/home/eck/sandbox/gnuradio/ornl-add/in2.txt</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>ornl_saxpy</key>
<param><key>id</key><value>ornl_saxpy_0</value></param>
<param><key>connected</key><value>5</value></param>
<param><key>device</key><value>128</value></param>
</block>
<block>
<key>ornl_vecadd</key>
<param><key>id</key><value>ornl_vecadd_0</value></param>
<param><key>connected</key><value>1</value></param>
<param><key>device</key><value>128</value></param>
<param><key>maxoutbuf</key><value>8192</value></param>
<param><key>minoutbuf</key><value>1</value></param>
</block>
<block>
<key>ornl_vecadd</key>
<param><key>id</key><value>ornl_vecadd_1</value></param>
<param><key>connected</key><value>4</value></param>
<param><key>device</key><value>64</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>ornl_saxpy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>ornl_vecadd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>ornl_vecadd_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_2</source_block_id><sink_block_id>ornl_saxpy_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>ornl_vecadd_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ornl_saxpy_0</source_block_id><sink_block_id>ornl_vecadd_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ornl_vecadd_0</source_block_id><sink_block_id>ornl_saxpy_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ornl_vecadd_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
